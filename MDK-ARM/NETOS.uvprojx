# Keil uVision project NETOS.uvprojx, settings and files
target NETOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: NETOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/system;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;  ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;  ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/posix;  ../Middlewares/Third_Party/LwIP/src/include/posix/sys;  ../Middlewares/Third_Party/LwIP/system/arch;  ../Drivers/CMSIS/Include;  ..\Drivers\BSP\STM32F429I-Discovery
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: lwip.c stm32f4xx_hal_msp.c freertos.c ethernetif.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c main.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c mld6.c inet6.c nd6.c ethip6.c ip6_addr.c ip6_frag.c icmp6.c ip6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4.c igmp.c ip4_addr.c autoip.c ip4_frag.c icmp.c etharp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: upap.c mppe.c ecp.c pppoe.c lcp.c pppapi.c multilink.c vj.c ipcp.c pppos.c pppol2tp.c magic.c ccp.c pppcrypt.c eap.c chap-md5.c auth.c utils.c chap-new.c demand.c eui64.c ppp.c ipv6cp.c fsm.c chap_ms.c
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c sockets.c err.c api_msg.c api_lib.c netbuf.c netdb.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: mem.c tcp_in.c tcp.c tcp_out.c timeouts.c def.c raw.c udp.c sys.c dns.c stats.c inet_chksum.c init.c memp.c ip.c netif.c pbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c queue.c event_groups.c tasks.c timers.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c
  group BSP/STM32F429I-Discovery
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
software components: CMSIS:CORE 5.0.2
