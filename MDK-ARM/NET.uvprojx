# Keil uVision project NET.uvprojx, settings and files
target NET (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: NET
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Inc;                      ../Middlewares/Third_Party/LwIP/src/include;                      ../Middlewares/Third_Party/LwIP/system;                      ../Drivers/STM32F4xx_HAL_Driver/Inc;                      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                      ../Middlewares/Third_Party/LwIP/src/include/lwip;                      ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                      ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                      ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                      ../Middlewares/Third_Party/LwIP/src/include/netif;                      ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                      ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;                      ../Middlewares/Third_Party/LwIP/src/include/posix;                      ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                      ../Middlewares/Third_Party/LwIP/system/arch;                      ../Drivers/CMSIS/Include;                      ..\Drivers\BSP\STM32F429I-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_eth.c stm32f4xx_hal_cortex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md4.c des.c sha1.c arc4.c md5.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c api_msg.c netbuf.c tcpip.c api_lib.c netifapi.c sockets.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c dhcp.c autoip.c etharp.c ip4_frag.c ip4_addr.c icmp.c igmp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppos.c chap-new.c multilink.c pppoe.c fsm.c ipcp.c upap.c pppapi.c chap_ms.c chap-md5.c eui64.c pppcrypt.c ecp.c magic.c utils.c lcp.c ppp.c ipv6cp.c mppe.c ccp.c eap.c auth.c demand.c pppol2tp.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c pbuf.c def.c udp.c inet_chksum.c sys.c memp.c timeouts.c tcp.c tcp_out.c stats.c mem.c raw.c ip.c dns.c netif.c init.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c ip6_addr.c mld6.c ip6_frag.c ethip6.c ip6.c inet6.c nd6.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c lwip.c stm32f4xx_it.c ethernetif.c main.c
  group Drivers/BSP
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
software components: CMSIS:CORE 5.0.1
